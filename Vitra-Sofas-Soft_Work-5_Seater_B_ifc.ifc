Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-12-20T16:06:51
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 20 16:06:51 2022 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\{0EAAB18A-E8E3-4381-A3E2-BA18BFD15529}\ifc * Database version: 5507 * Database creation date: Tue Dec 20 16:06:49 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 20 16:06:49 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 20 16:06:49 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFurnishingElement: Soft Work - Side panel, angled, Vitra-Sofas-Soft_Work-Accessories_rfa:Soft Work - Side panel, angled:794156
In: Level 1
Type - Material: Dark grey 69, Basic dark powder-coated 30
Type - Construction - AccessoriesType: Soft-Work_Accessories_Side-Panel-Angled
Type - Dimensions - NominalDepth: 709.1 mm; NominalHeight: 871.5 mm; NominalLength: 800 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Sofas-Soft_Work-Accessories_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_81; Uniclass2015Description: Sofas; Uniclass2015Reference: Pr_40_50_12_81; Version: 1; VersionDate: 13/12/2022
Type - Identity Data - Cost: 0; Manufacturer: Vitra; Model: Soft Work - Side panel, angled; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; Type Name: Soft Work - Side panel, angled
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Sofas-Soft_Work-Accessories_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Textile, metal; ModelNumber: n/a; ModelReference: n/a; Name: Soft_Work-Accessories_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: Variable; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; Host: Level : Level 1
Dimensions - Area: 0.62927 m2; Volume: 0.0568295 m3
Materials and Finishes - BaseMaterial: Basic dark powder-coated 30; CoverMaterial: Dark grey 69; TableTopMaterial: Basic dark powder-coated 30
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Sofas-Soft_Work-Accessories_rfa: Soft Work - Side panel, angled; Family and Type: Vitra-Sofas-Soft_Work-Accessories_rfa: Soft Work - Side panel, angled; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Sofas-Soft_Work-Accessories_rfa: Soft Work - Side panel, angled; Type Id: Vitra-Sofas-Soft_Work-Accessories_rfa: Soft Work - Side panel, angled; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction

# IfcFurnishingElement: Soft Work - Side table single, Vitra-Sofas-Soft_Work-Accessories_rfa:Soft Work - Side table single:794161
In: Level 1
Type - Material: Basic dark powder-coated 30
Type - Construction - AccessoriesType: Soft-Work_Accessories_Side-Table-Single
Type - Dimensions - NominalDepth: 709.1 mm; NominalHeight: 871.5 mm; NominalLength: 800 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Sofas-Soft_Work-Accessories_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_81; Uniclass2015Description: Sofas; Uniclass2015Reference: Pr_40_50_12_81; Version: 1; VersionDate: 13/12/2022
Type - Identity Data - Cost: 0; Manufacturer: Vitra; Model: Soft Work - Side table single; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; Type Name: Soft Work - Side table single
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Sofa; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Sofas-Soft_Work-Accessories_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Textile, metal; ModelNumber: n/a; ModelReference: n/a; Name: Soft_Work-Accessories_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: Variable; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.363329 m2; Volume: 0.0306891 m3
Materials and Finishes - BaseMaterial: Basic dark powder-coated 30; CoverMaterial: Dark grey 69; TableTopMaterial: Basic dark powder-coated 30
Other - Category: Furniture; AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Sofas-Soft_Work-Accessories_rfa: Soft Work - Side table single; Family and Type: Vitra-Sofas-Soft_Work-Accessories_rfa: Soft Work - Side table single; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Sofas-Soft_Work-Accessories_rfa: Soft Work - Side table single; Type Id: Vitra-Sofas-Soft_Work-Accessories_rfa: Soft Work - Side table single; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction

# IfcFurnishingElement: Soft Work - Sofa Lowback 1-seater (2)
In: Level 1
Type - Material: Basic dark powder-coated 30, Dark grey 69
Type - Construction - SeatType: Soft-Work_Seat_WithLowback
Type - Dimensions - NominalDepth: 709.1 mm; NominalHeight: 871.5 mm; NominalLength: 800 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Sofas-Soft_Work-1-seater_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_81; Uniclass2015Description: Sofas; Uniclass2015Reference: Pr_40_50_12_81; Version: 1; VersionDate: 13/12/2022
Type - Identity Data - Cost: 0; Manufacturer: Vitra; Model: Soft Work - Sofa Lowback 1-seater; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; Type Name: Soft Work - Sofa Lowback 1-seater
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Sofas-Soft_Work-1-seater_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Textile, metal; ModelNumber: n/a; ModelReference: n/a; Name: Soft_Work-1-seater_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 800x700x870 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - BaseType_LeftControl: Soft-Work_Base_Full; BaseType_RightControl: Soft-Work_Base_Full; LegVisibilty: no
Dimensions - Area: 1.88246 m2; Volume: 0.494385 m3
Materials and Finishes - BaseMaterial: Basic dark powder-coated 30; CoverMaterial: Dark grey 69; SurfaceMaterial: Polished Aluminium; TableTopMaterial: Basic dark powder-coated 30
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Sofas-Soft_Work-1-seater_rfa: Soft Work - Sofa Lowback 1-seater; Family and Type: Vitra-Sofas-Soft_Work-1-seater_rfa: Soft Work - Sofa Lowback 1-seater; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Sofas-Soft_Work-1-seater_rfa: Soft Work - Sofa Lowback 1-seater; Type Id: Vitra-Sofas-Soft_Work-1-seater_rfa: Soft Work - Sofa Lowback 1-seater; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
Name (Vitra-Sofas-Soft_Work-1-seater_rfa:Soft Work - Sofa Lowback 1-seater:...)
766426
794137

# IfcFurnishingElement: Soft Work - Sofa Lowback 1-seater (2)
In: Level 1
Type - Material: Polished Aluminium, Basic dark powder-coated 30, Dark grey 69
Type - Construction - SeatType: Soft-Work_Seat_WithLowback
Type - Dimensions - NominalDepth: 709.1 mm; NominalHeight: 871.5 mm; NominalLength: 800 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Sofas-Soft_Work-1-seater_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_81; Uniclass2015Description: Sofas; Uniclass2015Reference: Pr_40_50_12_81; Version: 1; VersionDate: 13/12/2022
Type - Identity Data - Cost: 0; Manufacturer: Vitra; Model: Soft Work - Sofa Lowback 1-seater; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; Type Name: Soft Work - Sofa Lowback 1-seater
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Sofas-Soft_Work-1-seater_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Textile, metal; ModelNumber: n/a; ModelReference: n/a; Name: Soft_Work-1-seater_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 800x700x870 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - BaseType_LeftControl: Soft-Work_Base_Full; BaseType_RightControl: Soft-Work_Base_End; LegVisibilty: yes
Dimensions - Area: 1.88246 m2; Volume: 0.494385 m3
Materials and Finishes - BaseMaterial: Basic dark powder-coated 30; CoverMaterial: Dark grey 69; SurfaceMaterial: Polished Aluminium; TableTopMaterial: Basic dark powder-coated 30
Other - Family: Vitra-Sofas-Soft_Work-1-seater_rfa: Soft Work - Sofa Lowback 1-seater; Family and Type: Vitra-Sofas-Soft_Work-1-seater_rfa: Soft Work - Sofa Lowback 1-seater; Type: Vitra-Sofas-Soft_Work-1-seater_rfa: Soft Work - Sofa Lowback 1-seater; Type Id: Vitra-Sofas-Soft_Work-1-seater_rfa: Soft Work - Sofa Lowback 1-seater; AssetIdentifier: n/a; Barcode: n/a; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
Name (Vitra-Sofas-Soft_Work-1-seater_rfa:Soft Work - Sofa Lowback 1-seater:...)
783819
783825

# IfcFurnishingElement: Soft Work - Table, Vitra-Sofas-Soft_Work-Table_rfa:Soft Work - Table:783807
In: Level 1
Type - Material: Polished Aluminium, Basic dark powder-coated 30
Type - Construction - TableType: Soft-Work_Table
Type - Dimensions - NominalDepth: 732 mm; NominalHeight: 323.999 mm; NominalLength: 800 mm
Type - General - Author: BIMStone; BIMObjectName: Vitra-Sofas-Soft_Work-Table_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_81; Uniclass2015Description: Sofas; Uniclass2015Reference: Pr_40_50_12_81; Version: 1; VersionDate: 12/12/2022
Type - Identity Data - Cost: 0; Manufacturer: Vitra; Model: Soft Work - Table; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; Type Name: Soft Work - Table
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Sofa; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Sofas-Soft_Work-Table_rfa; Features: n/a; Finish: n/a; Grade: n/a; Material: Textile, metal; ModelNumber: n/a; ModelReference: n/a; Name: Soft_Work-Table_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 696x696x324 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; Host: Level : Level 1
Dimensions - Area: 1.08197 m2; Volume: 0.189734 m3
Materials and Finishes - BaseMaterial: Basic dark powder-coated 30; SurfaceMaterial: Polished Aluminium; TableTopMaterial: Basic dark powder-coated 30
Other - Category: Furniture; AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Sofas-Soft_Work-Table_rfa: Soft Work - Table; Family and Type: Vitra-Sofas-Soft_Work-Table_rfa: Soft Work - Table; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Sofas-Soft_Work-Table_rfa: Soft Work - Table; Type Id: Vitra-Sofas-Soft_Work-Table_rfa: Soft Work - Table; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
